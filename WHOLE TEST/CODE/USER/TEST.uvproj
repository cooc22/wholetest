# Keil uVision project TEST.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: TEST +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\HARDWARE\BSP- LED;..\SYSTEM\delay;..\HARDWARE\BSP-SMG;..\HARDWARE\BSP- KEY;..\HARDWARE\BSP-LCD
  group Source Group 1
    ./: STARTUP.A51
  group HARDWARE
    ../HARDWARE/BSP-SMG/: SMG.c
    ../HARDWARE/BSP- KEY/: KEY.c
    ../HARDWARE/BSP-LCD/: LCD1602.c LCD12864.c
    ../HARDWARE/BSP- LED/: LED.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
  group USER
    ./: test.c
